Commit message: added plugin for lidar, imu and skid steering drive

File: urdf/urdf/rover.urdf (robot description, URDF)
Before this commit: robot rover, 14 links, 13 joints
Joints:
- joint Wheel_BL: axis 0 -1 0 -> 0 1 0
- joint Wheel_FL: axis 0 -1 0 -> 0 1 0
